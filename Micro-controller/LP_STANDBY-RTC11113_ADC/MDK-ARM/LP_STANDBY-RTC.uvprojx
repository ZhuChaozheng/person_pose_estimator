# Keil uVision project LP_STANDBY-RTC.uvprojx, settings and files
target LP_STANDBY-RTC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L051K8Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LP_STANDBY-RTC +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx,HAL_ADC_MODULE_ENABLED
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\BSP;..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_uart_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_uart.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_i2c.c stm32l0xx_hal.c stm32l0xx_hal_gpio.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_rtc.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c
  group BSP
    ../BSP/: BSP_debug.c BSP_pwr.c LIS3DH.c LIS3DH.h BSP_LRF215.C BSP_LRF215.H
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: rtc.c stm32l0xx_hal_msp.c usart.c stm32l0xx_it.c main.c gpio.c I2C.c I2C.h adc.c
software components: CMSIS:CORE 5.3.0
